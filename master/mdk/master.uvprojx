# Keil uVision project master.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: master
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\source\APP;..\source\CMSIS;..\source\HARDWARE;..\source\SYSTEM;..\source\STM32F10x_StdPeriph_Driver\inc;..\source\freertos\Source\portable\RVDS\ARM_CM3;..\source\freertos\Source\include;..\source\task;..\source\STM32_CPAL_Driver\inc;..\source\STM32_CPAL_Driver\devices\stm32f10x;..\source\matrixman-master;..\source\FFT_Library;..\source\rgbLibrary\inc;..\source\rgbMaxtrixLib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../source/APP/: CanApp.c main.c stm32f10x_it.c FreeRTOSHook.c maxtrixApp.c maxtrixApp.h
  group board
    ../source/HARDWARE/: eeprom.c led.c RGBMatrix.c RGBMatrix.h keyDetect.c keyDetect.h
  group sys
    ../source/SYSTEM/: can.c delay.c gpioInit.c iic.c iwdog.c rand.c sys.c sysclock.c wwdog.c
  group cmsis
    ../source/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_cl.s
  group stdlib
    ../source/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group rtos
    ../source/freertos/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../source/freertos/Source/portable/RVDS/ARM_CM3/: port.c
    ../source/freertos/Source/portable/MemMang/: heap_4.c
  group task
    ../source/task/: displayTask.c
  group rgbMaxtrixLib
    ../source/rgbMaxtrixLib/: rgbMaxtrixFront.h rgbMaxtrixFront.c
